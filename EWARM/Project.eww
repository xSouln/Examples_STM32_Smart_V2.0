<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Board_STM32_Smart_V2.0.ewp</path>
  </project>
  <batchBuild />
</workspace>

# Keil uVision project Board_STM32_Smart_V2.0.uvprojx, settings and files
target Board_STM32_Smart_V2.0 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Board_STM32_Smart_V2.0 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Libs/xLibMicrocontrollers;../Libs;../USB_DEVICE/App;../USB_DEVICE/Target;C:/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc;C:/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;C:/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;C:/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Include;../Adapters;../Communications;..\Components;..\Controls;..\Libs\WIZ\W5500;..\Libs\WIZ
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Application/Controls
    ../Controls/: Control.c Control.h Info.h Config.h Types.h
  group Application/Communications
    ../Communications/: RxRequests.c RxRequests.h RxTransactions.c RxTransactions.h
  group Components/RGBCups
    ../Components/RGBCups/: RGBCups_Component.c RGBCups_Components.h RGBCups_Config.h RGBCups_Info.h RGBCups_Types.h
  group Components/RGBCups/Adapters
    ../Components/RGBCups/Adapters/: RGBCup_Adapter.c RGBCup_Adapter.h RGBCup_AdapterConfig.h RGBCup_AdapterInfo.h RGBCup_AdapterTypes.h
  group Components/RGBCup/Controls
    ../Components/RGBCups/Controls/: RGBCups.c RGBCups.h
  group Components/RGBCups/Logic
    ../Components/RGBCups/Logic/: RGBCups_Logics.c RGBCups_Logics.h
  group Components/RGBCup/Communications
    ../Components/RGBCups/Communications/: RGBCups_RxRequests.c RGBCups_RxRequests.h RGBCups_RxTransactions.c RGBCups_RxTransactions.h
  group Components/SerialPort
    ../Components/SerialPort/: SerialPort_Config.h SerialPort_Info.h SerialPort_Types.h SerialPortUART_Component.c SerialPortUSB_Component.c SerialPort_Components.h
  group Components/SerialPort/Controls
    ../Components/SerialPort/Controls/: SerialPort.c SerialPort.h
  group Components/SerialPort/Adapters
    ../Components/SerialPort/Adapters/: SerialPort_Adapters.h SerialPort_AdaptersConfig.h SerialPort_AdaptersInfo.h SerialPort_AdaptersTypes.h
  group Components/SerialPort/Adapters/UART
    ../Components/SerialPort/Adapters/UART/: SerialPortUART_Adapter.c SerialPortUART_Adapter.h SerialPortUART_AdapterConfig.h SerialPortUART_AdapterInfo.h SerialPortUART_AdapterTypes.h SerialPortUART_RxAdapter.c SerialPortUART_RxAdapter.h SerialPortUART_TxAdapter.c SerialPortUART_TxAdapter.h
  group Components/SerialPort/Adapters/USB
    ../Components/SerialPort/Adapters/USB/: SerialPortUSB_Adapter.c SerialPortUSB_Adapter.h SerialPortUSB_AdapterConfig.h SerialPortUSB_AdapterInfo.h SerialPortUSB_AdapterTypes.h SerialPortUSB_RxAdapter.c SerialPortUSB_RxAdapter.h SerialPortUSB_TxAdapter.c SerialPortUSB_TxAdapter.h
  group Components/TCPServer
    ../Components/TCPServer/: TCPServer_Components.h TCPServer_Config.h TCPServer_Info.h TCPServer_Types.h TCPServerWIZspi_Component.c
  group Components/TCPServer/Controls
    ../Components/TCPServer/Controls/: TCPServer.c TCPServer.h
  group Components/TCPServer/Adapters
    ../Components/TCPServer/Adapters/: TCPServer_Adapters.h TCPServer_AdaptersConfig.h TCPServer_AdaptersInfo.h TCPServer_AdaptersTypes.h
  group Components/TCPServer/Adapters/WIZspi
    ../Components/TCPServer/Adapters/WIZspi/: TCPServerWIZspi_Adapter.c TCPServerWIZspi_Adapter.h TCPServerWIZspi_AdapterConfig.h TCPServerWIZspi_AdapterInfo.h TCPServerWIZspi_AdapterTypes.h TCPServerWIZspi_RxAdapter.c TCPServerWIZspi_RxAdapter.h TCPServerWIZspi_TxAdapter.c TCPServerWIZspi_TxAdapter.h
  group Libs/WIZ
    ../Libs/WIZ/W5500/: w5500.c w5500.h
    ../Libs/WIZ/: socket.c socket.h wizchip_conf.c wizchip_conf.h
  group Libs/WS2812
    ../Libs/WS2812/: WS2812.c WS2812.h WS2812_Config.h WS2812_Info.h
  group Libs/xLibMicrocontrollers/Common
    ../Libs/xLibMicrocontrollers/Common/: xDataBuffer.c xDataBuffer.h xRx.c xRx.h xTransferLayer.c xTransferLayer.h xTx.c xTx.h xRxRequest.c xRxRequest.h xRxTransaction.c xRxTransaction.h xCircleBuffer.c xCircleBuffer.h xMemory.c xMemory.h xRxReceiver.c xRxReceiver.h xTypes.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    C:/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    C:/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.6.0
